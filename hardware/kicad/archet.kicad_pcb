# Repository Otatiaro/archet (continued)

## KiCad design hardware/kicad/archet.kicad_pcb (continued)

Schematic: mcu.kicad_sch, MCU: STM32H723ZGT6, decoupling, HSE, debug connector

Parts:
C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C46, C47, C48: 100nF; C_0402_1005Metric; LCSC C307331
C42: 10µF 25V; C_0805_2012Metric; LCSC C15850
C43, C44: 2.2µF; C_0402_1005Metric; LCSC C12530
C45: 1µF 50V; C_0603_1608Metric; LCSC C15849
C49, C50: 15pF; C_0402_1005Metric; LCSC C1548
D8, D9: 1N5819WS; D_SOD-323; LCSC C191023
FB1: 600Ω@100MHz; L_0603_1608Metric; LCSC C1002
J4: MCU debug (TC2030); Tag-Connect_TC2030-IDC-FP_2x03_P1.27mm_Vertical
J6: Console / bootloader (FTDI); PinHeader_1x06_P2.54mm_Vertical
R21: 22k; R_0402_1005Metric; LCSC C25768
R175: 33; R_0402_1005Metric; LCSC C25105
R177: 1k; R_0402_1005Metric; LCSC C11702
U11: STM32H723ZGT6; LQFP-144_20x20mm_P0.5mm; LCSC C730146
Y1: 25MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm; LCSC C9006

Connections:
+3V3: C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C47.1, FB1.1, J4.1 (VCC), U11.6 (VBAT), U11.17 (VDD), U11.30 (VDD), U11.39 (VDD), U11.52 (VDD), U11.62 (VDD), U11.72 (VDD), U11.84 (VDD), U11.95 (VDD33USB), U11.108 (VDD), U11.121 (VDD), U11.131 (VDD), U11.143 (PDR_ON), U11.144 (VDD); also elsewhere on the board
/MCU/CONSOLE_RX: J6.4, U11.78 (PD9)
/MCU/CONSOLE_TX: J6.5, U11.77 (PD8)
/MCU/HSE_IN: C49.1, U11.23 (PH0), Y1.1
/MCU/HSE_OUT: C50.1, U11.24 (PH1), Y1.3
/MCU/J6_RST: D9.1 (K), J6.6
/MCU/J6_VCC: D8.2 (A), J6.3, R177.2
/MCU/MCU_SWCLK: J4.4 (SWCLK), U11.109 (PA14(JTCK)
/MCU/MCU_SWDIO: J4.2 (SWDIO), U11.105 (PA13(JTMS)
/MCU/MCU_SWO: J4.6 (SWO), U11.133 (PB3(JTDO)
/MCU/NRST: C48.1, D9.2 (A), J4.3 (~RESET), U11.25 (NRST)
/MCU/VCAP: C43.1, C44.1, U11.71 (VCAP), U11.106 (VCAP)
/MCU/VDDA: C45.1, C46.1, FB1.2, U11.32 (VREF+), U11.33 (VDDA)
BOOST_EN: U11.86 (PD15); also elsewhere on the board
BOOT0: J6.2, R21.1, U11.138 (BOOT0); also elsewhere on the board
BUS_3V3_EN: U11.118 (PD4); also elsewhere on the board
BUS_3V3_FLT: U11.123 (PD7); also elsewhere on the board
BUS_CS0: U11.141 (PE0); also elsewhere on the board
BUS_CS1: U11.142 (PE1); also elsewhere on the board
BUS_CS2: U11.68 (PE15); also elsewhere on the board
BUS_CS3: U11.2 (PE3); also elsewhere on the board
BUS_CS4: U11.3 (PE4); also elsewhere on the board
BUS_CS5: U11.4 (PE5); also elsewhere on the board
BUS_CS6: U11.5 (PE6); also elsewhere on the board
BUS_CS7: U11.58 (PE7); also elsewhere on the board
BUS_CS8: U11.59 (PE8); also elsewhere on the board
BUS_CS9: U11.60 (PE9); also elsewhere on the board
BUS_CS10: U11.63 (PE10); also elsewhere on the board
BUS_CS11: U11.92 (PG7); also elsewhere on the board
BUS_IRQ: U11.80 (PD11); also elsewhere on the board
BUS_LATCH: U11.110 (PA15(JTDI)); also elsewhere on the board
BUS_MISO: U11.75 (PB14); also elsewhere on the board
BUS_MOSI: U11.76 (PB15); also elsewhere on the board
BUS_OE: U11.85 (PD14); also elsewhere on the board
BUS_SCK: U11.117 (PD3); also elsewhere on the board
BUS_SCL: U11.136 (PB6); also elsewhere on the board
BUS_SDA: U11.137 (PB7); also elsewhere on the board
BUZZER: U11.140 (PB9); also elsewhere on the board
CC_HS_SENSE: U11.42 (PA6); also elsewhere on the board
EFUSE_3V3_EN: U11.97 (PC7); also elsewhere on the board
EFUSE_3V3_FLT: U11.101 (PA9); also elsewhere on the board
EFUSE_5V_EN: U11.96 (PC6); also elsewhere on the board
EFUSE_5V_FLT: U11.100 (PA8); also elsewhere on the board
ETH_PHY_RST: U11.91 (PG6); also elsewhere on the board
FIELD_RX: U11.114 (PD0); also elsewhere on the board
FIELD_SEL_485: U11.48 (PB2); also elsewhere on the board
FIELD_TX: U11.115 (PD1); also elsewhere on the board
FLASH_CLK: U11.22 (PF10); also elsewhere on the board
FLASH_IO0: U11.20 (PF8); also elsewhere on the board
FLASH_IO1: U11.21 (PF9); also elsewhere on the board
FLASH_IO2: U11.1 (PE2); also elsewhere on the board
FLASH_IO3: U11.18 (PF6); also elsewhere on the board
FLASH_NCS: U11.64 (PE11); also elsewhere on the board
FPGA_CDONE: U11.90 (PG5); also elsewhere on the board
FPGA_CRESET_B: U11.89 (PG4); also elsewhere on the board
FPGA_IRQ: U11.88 (PG3); also elsewhere on the board
FPGA_QSPI_CLK: U11.14 (PF4); also elsewhere on the board
FPGA_QSPI_IO0: U11.10 (PF0); also elsewhere on the board
FPGA_QSPI_IO1: U11.11 (PF1); also elsewhere on the board
FPGA_QSPI_IO2: U11.12 (PF2); also elsewhere on the board
FPGA_QSPI_IO3: U11.13 (PF3); also elsewhere on the board
FPGA_QSPI_NCS: U11.127 (PG12); also elsewhere on the board
FPGA_REFCLK: U11.99 (PC9); also elsewhere on the board
GND: C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, J4.5 (GND), J6.1, R21.2, R177.1, U11.16 (VSS), U11.31 (VSSA), U11.38 (VSS), U11.51 (VSS), U11.61 (VSS), U11.83 (VSS), U11.94 (VSS), U11.107 (VSS), U11.120 (VSS), U11.130 (VSS), Y1.2 (G), Y1.4 (G); also elsewhere on the board
GO_BTN: U11.55 (PF15); also elsewhere on the board
INA_ALERT: U11.57 (PG1); also elsewhere on the board
LED_FAIL: U11.102 (PA10); also elsewhere on the board
LED_PASS: U11.67 (PE14); also elsewhere on the board
LED_STATUS: U11.139 (PB8); also elsewhere on the board
PD_ALERT: U11.56 (PG0); also elsewhere on the board
POE_12V_SENSE: U11.54 (PF14); also elsewhere on the board
POE_AT_N: U11.9 (PC15); also elsewhere on the board
PPS: R175.1, U11.93 (PG8); also elsewhere on the board
PPS_IN: R175.2, U11.34 (PA0)
RMII_CRS_DV: U11.43 (PA7); also elsewhere on the board
RMII_MDC: U11.27 (PC1); also elsewhere on the board
RMII_MDIO: U11.36 (PA2); also elsewhere on the board
RMII_REF_CLK: U11.35 (PA1); also elsewhere on the board
RMII_RXD0: U11.44 (PC4); also elsewhere on the board
RMII_RXD1: U11.45 (PC5); also elsewhere on the board
RMII_TXD0: U11.128 (PG13); also elsewhere on the board
RMII_TXD1: U11.129 (PG14); also elsewhere on the board
RMII_TX_EN: U11.126 (PG11); also elsewhere on the board
RS485_DE: U11.132 (PG15); also elsewhere on the board
SHIELD_PRESENT_N: U11.8 (PC14); also elsewhere on the board
SHIELD_RESET_N: U11.125 (PG10); also elsewhere on the board
SHIELD_SCL: U11.81 (PD12); also elsewhere on the board
SHIELD_SDA: U11.82 (PD13); also elsewhere on the board
SHIELD_SWCLK: U11.65 (PE12); also elsewhere on the board
SHIELD_SWDIO: U11.66 (PE13); also elsewhere on the board
SHIELD_UART_RX: U11.116 (PD2); also elsewhere on the board
SHIELD_UART_TX: U11.113 (PC12); also elsewhere on the board
STOP_BTN: U11.7 (PC13); also elsewhere on the board
SYS_SCL: U11.112 (PC11); also elsewhere on the board
SYS_SDA: U11.111 (PC10); also elsewhere on the board
TGT_NRST_SENSE: U11.134 (PB4(NJTRST)); also elsewhere on the board
TGT_VSET: U11.40 (PA4); also elsewhere on the board
TGT_VSUP_EN: U11.98 (PC8); also elsewhere on the board
ULPI_CK: U11.41 (PA5); also elsewhere on the board
ULPI_D0: U11.37 (PA3); also elsewhere on the board
ULPI_D1: U11.46 (PB0); also elsewhere on the board
ULPI_D2: U11.47 (PB1); also elsewhere on the board
ULPI_D3: U11.69 (PB10); also elsewhere on the board
ULPI_D4: U11.70 (PB11); also elsewhere on the board
ULPI_D5: U11.73 (PB12); also elsewhere on the board
ULPI_D6: U11.74 (PB13); also elsewhere on the board
ULPI_D7: U11.135 (PB5); also elsewhere on the board
ULPI_DIR: U11.28 (PC2_C); also elsewhere on the board
ULPI_NXT: U11.29 (PC3_C); also elsewhere on the board
ULPI_RST: U11.79 (PD10); also elsewhere on the board
ULPI_STP: U11.26 (PC0); also elsewhere on the board
USB_FS_DM: U11.103 (PA11); also elsewhere on the board
USB_FS_DP: U11.104 (PA12); also elsewhere on the board
VBUS_USB_SENSE: U11.53 (PF13); also elsewhere on the board
VIN_BUS1_EN: U11.87 (PG2); also elsewhere on the board
VIN_BUS2_EN: U11.124 (PG9); also elsewhere on the board
VIN_BUS_IMON: U11.19 (PF7); also elsewhere on the board
VIN_BUS_SENSE: U11.15 (PF5); also elsewhere on the board
VIN_EXT_SENSE: U11.50 (PF12); also elsewhere on the board
VSYS: D8.1 (K); also elsewhere on the board
VTREF_SENSE: U11.49 (PF11); also elsewhere on the board

Notes on the sheet:
MCU
STM32H723ZGT6, LQFP-144. Pin assignment: hardware/mcu-pins.csv (checked by pincheck.py); unlisted pins carry a no-connect flag. Layout: one 100 nF per VDD pin against the pin, VCAP capacitors against pins 71 and 106, crystal and load capacitors next to PH0/PH1 with a ground guard.
11 x 100 nF: one per VDD pin. C47: VDD33USB. C42: bulk
PPS loopback
PG8 (ETH_PPS_OUT) to PA0 (TIM2_ETR): TIM2 restarts on the PTP second, LATCH follows it. R175 not fitted if TIM2 has an internal ETH PPS trigger.
TC2030 footprint, nothing to fit: J-Link through the SEGGER 6-pin Needle Adapter or a TC2030-CTX cable.
Programming with no probe: ROM bootloader (AN2606)
Hold GO at power-up or reset: R24 (1k, UI sheet) lifts BOOT0 to 3.16 V against R21. DFU through the internal FS PHY on J2 (USB-C sheet), or USART3 through J6 below.
J6: pads only, FTDI cable pinout (TTL-232R-5V or adapter with 5 V on VCC). VCC powers the board (D8). RTS resets through D9: NRST is not 5 V tolerant. Pin 2 (CTS) is a BOOT0 test pad: an adapter driving CTS high enters the bootloader.

Schematic: buck3v3.kicad_sch, +3V3 and +3V3_AUX rails: two TLV62569 bucks from +5V

Parts:
C27, C29: 10µF 25V; C_0805_2012Metric; LCSC C15850
C28, C30: 22µF 25V; C_1206_3216Metric; LCSC C12891
L2, L3: 2.2µH; L_Changjiang_FXL0420; LCSC C167206
R17, R19: 100k; R_0402_1005Metric; LCSC C25741
R18, R20: 22k; R_0402_1005Metric; LCSC C25768
U9, U10: TLV62569DBVR; SOT-23-5; LCSC C141836

Connections:
+3V3: C28.1, L2.2, R17.1; also elsewhere on the board
+3V3_AUX: C30.1, L3.2, R19.1; also elsewhere on the board
+5V: C27.1, C29.1, U9.1 (EN), U9.4 (VIN), U10.1 (EN), U10.4 (VIN); also elsewhere on the board
/+3V3/B3V3A_FB: R19.2, R20.1, U10.5 (FB)
/+3V3/B3V3A_SW: L3.1, U10.3 (SW)
/+3V3/B3V3_FB: R17.2, R18.1, U9.5 (FB)
/+3V3/B3V3_SW: L2.1, U9.3 (SW)
GND: C27.2, C28.2, C29.2, C30.2, R18.2, R20.2, U9.2 (GND), U10.2 (GND); also elsewhere on the board

Notes on the sheet:
+3V3 / +3V3_AUX BUCKS
Two identical 2 A converters: +3V3 feeds the probe (520 mA max), +3V3_AUX feeds the 3V3_OUT eFuse (1 A ceiling), so a shield or target short never pulls the probe rail down. Layout: input capacitor against VIN and GND, short SW node, FB divider away from the inductor.
To the MCU, FPGA LDO, PHYs and logic
To the 3V3_OUT eFuse (shield)

Schematic: boost.kicad_sch, VIN_BUS: LM5155 24.5 V boost from VSYS, or VIN_EXT

Parts:
C113: 100pF; C_0402_1005Metric; LCSC C1546
C114, C118, C125: 100nF; C_0402_1005Metric; LCSC C307331
C115: 470pF; C_0402_1005Metric; LCSC C1537
C116: 22nF; C_0402_1005Metric; LCSC C1532
C117, C135: 1µF 50V; C_0603_1608Metric; LCSC C15849
C119, C120, C121, C122, C123, C124: 10µF 50V; C_1206_3216Metric; LCSC C13585
D17: SS54; D_SMA; LCSC C22452
L5: 10µH; L_Changjiang_FXL1040; LCSC C475915
Q8, Q10: CSD18543Q3A; VSON-8_3.3x3.3mm_P0.65mm_NexFET; LCSC C840100
Q9: 2N7002; SOT-23; LCSC C8545
R113: 51k; R_0402_1005Metric; LCSC C25794
R114, R123: 47k; R_0402_1005Metric; LCSC C25792
R115: 2k; R_0402_1005Metric; LCSC C4109
R116: 15m; R_1206_3216Metric; LCSC C844483
R117: 470; R_0402_1005Metric; LCSC C25117
R118: 100; R_0402_1005Metric; LCSC C25076
R119: 3.3k; R_0402_1005Metric; LCSC C25890
R120, R125: 10k; R_0402_1005Metric; LCSC C25744
R121: 22k; R_0402_1005Metric; LCSC C25768
R122, R124: 100k; R_0402_1005Metric; LCSC C25741
U42: LM5155DSSR; WSON-12-1EP_3x2mm_P0.5mm_EP1x2.65; LCSC C545416
U52: MX74700T; SOT-23-6; LCSC C22468156

Connections:
/VIN_BUS/BOOST_COMP: C115.1, R119.1, U42.6 (COMP)
/VIN_BUS/BOOST_CS: C113.1, R118.2, U42.5 (CS)
/VIN_BUS/BOOST_CSF: R117.2, R118.1
/VIN_BUS/BOOST_CZ: C114.1, R119.2
/VIN_BUS/BOOST_FB: R114.2, R115.1, U42.8 (FB)
/VIN_BUS/BOOST_GATE: Q8.4 (G), U42.3 (GATE)
/VIN_BUS/BOOST_INH: Q9.1 (G), R122.2, R123.1
/VIN_BUS/BOOST_ISNS: Q8.1 (S), Q8.2 (S), Q8.3 (S), R116.1, R117.1
/VIN_BUS/BOOST_RT: R113.1, U42.10 (RT)
/VIN_BUS/BOOST_SS: C116.1, U42.9 (SS)
/VIN_BUS/BOOST_SW: D17.2 (A), L5.2, Q8.5 (D)
/VIN_BUS/BOOST_UVLO: Q9.3 (D), R120.2, R121.1, U42.12 (UVLO/EN/SYNC)
/VIN_BUS/BOOST_VCC: C117.1, U42.2 (VCC)
/VIN_BUS/GATE4: Q10.4 (G), U52.5 (GATE)
/VIN_BUS/VCAP4: C135.2, U52.1 (VCAP)
BOOST_EN: R120.1; also elsewhere on the board
GND: C113.2, C114.2, C115.2, C116.2, C117.2, C118.2, C119.2, C120.2, C121.2, C122.2, C123.2, C124.2, C125.2, Q9.2 (S), R113.2, R115.2, R116.2, R121.2, R123.2, R125.2, U42.4 (PGND), U42.7 (AGND), U42.13 (EP), U52.2 (GND); also elsewhere on the board
VIN_BUS: C121.1, C122.1, C123.1, C124.1, D17.1 (K), Q10.5 (D), R114.1, R124.1, U52.4 (CATHODE); also elsewhere on the board
VIN_BUS_SENSE: C125.1, R124.2, R125.1; also elsewhere on the board
VIN_EXT_P: C135.1, Q10.1 (S), Q10.2 (S), Q10.3 (S), R122.1, U52.3 (EN), U52.6 (ANODE); also elsewhere on the board
VSYS: C118.1, C119.1, C120.1, L5.1, U42.1 (BIAS); also elsewhere on the board

Notes on the sheet:
VIN_BUS BOOST
VIN_BUS = the higher of the boost (24.5 V) and VIN_EXT through U52/Q10. With VIN_EXT present, Q9 holds UVLO low: a 12 V VIN_EXT is passed through, never boosted. On USB or PoE the firmware enables the boost (BOOST_EN) within the source budget. Values simulated in hardware/sim/boost.py. Layout: C119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
From the Sources sheet
From PD15
BOOST_EN low or high-Z: off. VIN_EXT >= 10.8 V: gate >= 3.4 V, off.
To the local bus switches (TPS27S100B x 2)
VIN_EXT path: MX74700T ideal diode, as on the Sources sheet. Blocks the boost output (no leakage into VIN_EXT_P, which drives Q9), and a reversed VIN_EXT with the boost running.
VIN_BUS_SENSE to PF5.

Schematic: buck5.kicad_sch, +5V rail: LMR33630 synchronous buck from VSYS

Parts:
C19, C20: 10µF 50V; C_1206_3216Metric; LCSC C13585
C21, C23: 100nF; C_0402_1005Metric; LCSC C307331
C22: 1µF 50V; C_0603_1608Metric; LCSC C15849
C24, C25, C26: 22µF 25V; C_1206_3216Metric; LCSC C12891
L1: 10µH; L_Changjiang_FXL0630; LCSC C167223
R15: 8.06k; R_0402_1005Metric; LCSC C25923
R16: 2k; R_0402_1005Metric; LCSC C4109
U8: LMR33630ADDAR; Texas_HSOP-8-1EP_3.9x4.9mm_P1.27mm_ThermalVias; LCSC C841384

Connections:
+5V: C24.1, C25.1, C26.1, L1.2, R15.1; also elsewhere on the board
/+5V/BUCK5_BOOT: C23.1, U8.7 (BOOT)
/+5V/BUCK5_FB: R15.2, R16.1, U8.5 (FB)
/+5V/BUCK5_SW: C23.2, L1.1, U8.8 (SW)
/+5V/BUCK5_VCC: C22.1, U8.6 (VCC)
GND: C19.2, C20.2, C21.2, C22.2, C24.2, C25.2, C26.2, R16.2, U8.1 (GND), U8.9 (GND); also elsewhere on the board
VSYS: C19.1, C20.1, C21.1, U8.2 (VIN), U8.3 (EN); also elsewhere on the board

Notes on the sheet:
+5V BUCK
VSYS 4.5-24 V -> +5V 3 A (15 W). On a 5 V USB port the converter runs in dropout (~98 % duty): +5V ~ 4.8 V, enough for the TLV62569 bucks; the firmware keeps 5V_OUT off. Layout: C21 and C19/C20 against VIN and the PGND pad, short SW node, FB divider away from L1.
From the Sources sheet
To the TLV62569 bucks, the 5V_OUT eFuse, the ULPI PHY and the target supply

Schematic: poe.kicad_sch, PoE+ input: RJ45 magnetics, polarity bridges, isolated 12 V…

Parts:
C17: 100µF 25V; CP_Elec_6.3x7.7; LCSC C970685
C18: 10µF 25V; C_0805_2012Metric; LCSC C15850
D4, D5: MB10S; TO-269AA; LCSC C2488
D6: SMAJ58A; D_SMA; LCSC C10762
J3: ARJM11D7-104-AB-EW2; ARJM11_Layout7_10P_LED; LCSC C5554250
R12: 47k; R_0805_2012Metric; LCSC C17713
R13: 100k; R_0402_1005Metric; LCSC C25741
R14: 1k; R_1206_3216Metric; LCSC C4410
U6: DP5700-12V2A; DP5700; LCSC C22358555
U7: PC817X2CSP9F; SMDIP-4_W7.62mm; LCSC C66405

Connections:
+3V3: R13.1; also elsewhere on the board
/PoE/POE_DA: D4.2, J3.9 (VC2+)
/PoE/POE_DB: D4.1, J3.10 (VC2-)
/PoE/POE_OPTO_A: R12.2, U7.1
/PoE/POE_SA: D5.2, J3.7 (VC1+)
/PoE/POE_SB: D5.1, J3.8 (VC1-)
/PoE/POE_TYP2: U6.5 (TYP2-DET), U7.2
/PoE/POE_VN: D4.4 (-), D5.4 (-), D6.2 (A2), U6.6 (VIN-)
/PoE/POE_VP: D4.3 (+), D5.3 (+), D6.1 (A1), R12.1, U6.4 (VIN+)
ETH_CT: J3.5 (CT); also elsewhere on the board
ETH_LEDL_A: J3.13 (LED_L+); also elsewhere on the board
ETH_LEDR_A: J3.11 (LED_R+); also elsewhere on the board
ETH_RXN: J3.4 (RD-); also elsewhere on the board
ETH_RXP: J3.3 (RD+); also elsewhere on the board
ETH_TXN: J3.2 (TD-); also elsewhere on the board
ETH_TXP: J3.1 (TD+); also elsewhere on the board
GND: C17.2, C18.2, J3.12 (LED_R-), J3.14 (LED_L-), J3.SH (SHIELD), R14.2, U6.2 (-VDC), U7.3; also elsewhere on the board
POE_12V: C17.1, C18.1, R14.1, U6.1 (+VDC); also elsewhere on the board
POE_AT_N: R13.2, U7.4; also elsewhere on the board

Notes on the sheet:
POE+ INPUT
Modes A and B: one bridge on the data pair centre taps, one on the spare pairs. The DP5700 signs as a class 4 PD and delivers an isolated 12 V; the primary side (POE_VP / POE_VN) never touches GND. TYP2-DET crosses the barrier through an opto: POE_AT_N low = 25.5 W budget.
To the Sources sheet (ideal diode 3)
To PC15 (MCU)
To the LAN8742A (PHY sheet). LEDs: left green, right yellow; anodes driven by the PHY.

Schematic: usbc_hs.kicad_sch, USB-C HS port (J5): 5 V sink, soft start, ideal diode

Parts:
C12, C137: 100nF; C_0402_1005Metric; LCSC C307331
C136, C138, C139, C140: 1µF 50V; C_0603_1608Metric; LCSC C15849
D7: SMBJ24CA; D_SMB; LCSC C78416
D20: ESDA25W; SOT-323_SC-70; LCSC C2935152
D21: 1N5819WS; D_SOD-323; LCSC C191023
J5: TYPE-C-31-M-12; USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC C165948
Q11: AO4407A; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C2841482
Q12: CSD18543Q3A; VSON-8_3.3x3.3mm_P0.65mm_NexFET; LCSC C840100
R7, R8, R179: 100k; R_0402_1005Metric; LCSC C25741
R25, R176: 5.1k; R_0402_1005Metric; LCSC C25905
R180: 22k; R_0402_1005Metric; LCSC C25768
U12: USBLC6-2SC6; SOT-23-6; LCSC C7519
U53: MX74700T; SOT-23-6; LCSC C22468156

Connections:
+3V3: U12.5 (VBUS); also elsewhere on the board
/USB-C HS/CC1_HS: D20.2 (K), J5.A5 (CC1), R7.1, R25.2
/USB-C HS/CC2_HS: D20.1 (K), J5.B5 (CC2), R8.1, R176.1
/USB-C HS/GATE5: Q12.4 (G), U53.5 (GATE)
/USB-C HS/HS_C_DM: J5.A7 (D-), J5.B7 (D-), U12.1 (I/O1)
/USB-C HS/HS_C_DP: J5.A6 (D+), J5.B6 (D+), U12.3 (I/O2)
/USB-C HS/HS_GATE: C136.2, C137.2, D21.1 (K), Q11.4 (G), R179.2, R180.1
/USB-C HS/VBUS_HS: C137.1, C139.1, C140.1, Q11.5 (D), Q11.6 (D), Q11.7 (D), Q11.8 (D), Q12.1 (S), Q12.2 (S), Q12.3 (S), U53.3 (EN), U53.6 (ANODE)
/USB-C HS/VCAP5: C139.2, U53.1 (VCAP)
CC_HS_SENSE: C12.1, R7.2, R8.2; also elsewhere on the board
GND: C12.2, C138.2, C140.2, D7.1 (A1), D20.3 (A), D21.2 (A), J5.A1 (GND), J5.A12 (GND), J5.B1 (GND), J5.B12 (GND), J5.SH (SHIELD), R25.1, R176.2, R180.2, U12.2 (GND), U53.2 (GND); also elsewhere on the board
USB_DM: U12.6 (I/O1); also elsewhere on the board
USB_DP: U12.4 (I/O2); also elsewhere on the board
VBUS_HS_CONN: C136.1, C138.1, D7.2 (A2), J5.A4 (VBUS), J5.A9 (VBUS), J5.B4 (VBUS), J5.B9 (VBUS), Q11.1 (S), Q11.2 (S), Q11.3 (S), R179.1; also elsewhere on the board
VSYS_OR: Q12.5 (D), U53.4 (CATHODE); also elsewhere on the board

Notes on the sheet:
USB-C HS PORT (J5)
USB 2.0 HS to the USB3320C, 5 V only (Rd on both CC lines, no PD): a PC port, Type-A cable or Type-C. Q11 soft start limits the attach inrush (USB 2.0: 10 µF / 50 µC) against ~90 µF on VSYS, then ideal diode 5.
To the USB3320C VBUS (R30, ULPI sheet)
To the Sources sheet (VSYS_OR bus)
PA6 (ADC1_INP3) reads 0.51 x vRd of the active CC: < 0.34 V default USB, 0.34-0.63 V 1.5 A, > 0.63 V 3 A. Rd seen by the source: 5.1k // 200k = 4.98 kΩ.
To the USB3320C (ULPI sheet)

Schematic: usbc.kicad_sch, USB-C PD port (J2): STUSB4500 sink, VBUS switch, USB FS, ESD

Parts:
C13, C14, C15, C134: 1µF 50V; C_0603_1608Metric; LCSC C15849
C16, C141: 100nF; C_0402_1005Metric; LCSC C307331
D2: SMBJ24CA; D_SMB; LCSC C78416
D3: ESDA25W; SOT-323_SC-70; LCSC C2935152
J2: TYPE-C-31-M-12; USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC C165948
Q4: AO4407A; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C2841482
R9, R181: 1k; R_0402_1005Metric; LCSC C11702
R10, R22, R23: 100k; R_0402_1005Metric; LCSC C25741
R11: 10k; R_0402_1005Metric; LCSC C25744
U4: STUSB4500QTR; QFN-24-1EP_4x4mm_P0.5mm_EP2.7x2.7mm; LCSC C2678061
U5: USBLC6-2SC6; SOT-23-6; LCSC C7519

Connections:
+3V3: C16.1, U4.22 (VSYS), U5.5 (VBUS); also elsewhere on the board
/USB-C/CC1: D3.2 (K), J2.A5 (CC1), U4.1 (CC1DB), U4.2 (CC1)
/USB-C/CC2: D3.1 (K), J2.B5 (CC2), U4.4 (CC2), U4.5 (CC2DB)
/USB-C/PD_1V2: C14.1, U4.21 (VREG_1V2)
/USB-C/PD_2V7: C15.1, U4.23 (VREG_2V7)
/USB-C/PD_DISCH: R9.2, U4.18 (VBUS_VS_DISCH)
/USB-C/USB_C_DM: J2.A7 (D-), J2.B7 (D-), U5.1 (I/O1)
/USB-C/USB_C_DP: J2.A6 (D+), J2.B6 (D+), U5.3 (I/O2)
/USB-C/VBUS_EN_N: R11.2, U4.16 (VBUS_EN_SNK)
/USB-C/VBUS_GATE: C134.2, Q4.4 (G), R10.2, R11.1, R181.2
/USB-C/VBUS_MILLER: C141.2, R181.1
GND: C13.2, C14.2, C15.2, C16.2, D2.1 (A1), D3.3 (A), J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.SH (SHIELD), R22.1, R23.2, U4.6 (RESET), U4.10 (GND), U4.12 (ADDR0), U4.13 (ADDR1), U4.25 (GND), U5.2 (GND); also elsewhere on the board
PD_ALERT: U4.19 (ALERT); also elsewhere on the board
SYS_SCL: U4.7 (SCL); also elsewhere on the board
SYS_SDA: U4.8 (SDA); also elsewhere on the board
USB_FS_DM: R22.2, U5.6 (I/O1); also elsewhere on the board
USB_FS_DP: R23.1, U5.4 (I/O2); also elsewhere on the board
VBUS_CONN: C13.1, C134.1, D2.2 (A2), J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), Q4.1 (S), Q4.2 (S), Q4.3 (S), R9.1, R10.1, U4.24 (VDD)
VBUS_USB: C141.1, Q4.5 (D), Q4.6 (D), Q4.7 (D), Q4.8 (D); also elsewhere on the board

Notes on the sheet:
USB-C PD PORT (J2)
The STUSB4500 negotiates the highest PDO stored in its NVM, then closes Q4 (VBUS_EN_SNK low). Dead battery mode: with the probe unpowered, CCxDB presents Rd so that the source turns VBUS on.
To the Sources sheet (ideal diode 2)
To the MCU internal FS PHY (PA11 / PA12): ROM DFU only. R22/R23: known level with J2 open.
SYS_SCL / SYS_SDA: I2C5, pull-ups R63/R64 on the target supply sheet. PD_ALERT: PG0, MCU pull-up.

Schematic: sources.kicad_sch, Source OR-ing into VSYS: VIN_EXT, USB-C VBUS, PoE 12 V

Parts:
C1, C2, C3, C4, C5, C6, C8: 1µF 50V; C_0603_1608Metric; LCSC C15849
C7: 47µF 63V; CP_Elec_6.3x7.7; LCSC C46550423
C9, C10, C11, C126: 100nF; C_0402_1005Metric; LCSC C307331
D1: SMBJ24CA; D_SMB; LCSC C78416
F1: 5A 63V; Fuse_1206_3216Metric; LCSC C2980745
J1: VIN_EXT; PhoenixContact_MC_1,5_2-G-3.81_1x02_P3.81mm_Horizontal; LCSC C441182
Q1, Q2, Q3: CSD18543Q3A; VSON-8_3.3x3.3mm_P0.65mm_NexFET; LCSC C840100
R1, R3, R5: 100k; R_0402_1005Metric; LCSC C25741
R2, R4, R6: 10k; R_0402_1005Metric; LCSC C25744
R126: 15m; R_1206_3216Metric; LCSC C844483
U1, U2, U3: MX74700T; SOT-23-6; LCSC C22468156
U43: INA226AIDGSR; TSSOP-10_3x3mm_P0.5mm; LCSC C49851

Connections:
+3V3: C126.1, U43.2 (A0), U43.6 (VS); also elsewhere on the board
/Sources/GATE1: Q1.4 (G), U1.5 (GATE)
/Sources/GATE2: Q2.4 (G), U2.5 (GATE)
/Sources/GATE3: Q3.4 (G), U3.5 (GATE)
/Sources/VCAP1: C1.2, U1.1 (VCAP)
/Sources/VCAP2: C3.2, U2.1 (VCAP)
/Sources/VCAP3: C5.2, U3.1 (VCAP)
GND: C2.2, C4.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C126.2, D1.1 (A1), J1.2, R2.2, R4.2, R6.2, U1.2 (GND), U2.2 (GND), U3.2 (GND), U43.1 (A1), U43.7 (GND); also elsewhere on the board
INA_ALERT: U43.3 (~Alert); also elsewhere on the board
POE_12V: C5.1, C6.1, Q3.1 (S), Q3.2 (S), Q3.3 (S), R5.1, U3.3 (EN), U3.6 (ANODE); also elsewhere on the board
POE_12V_SENSE: C11.1, R5.2, R6.1; also elsewhere on the board
SYS_SCL: U43.5 (SCL); also elsewhere on the board
SYS_SDA: U43.4 (SDA); also elsewhere on the board
VBUS_USB: C3.1, C4.1, Q2.1 (S), Q2.2 (S), Q2.3 (S), R3.1, U2.3 (EN), U2.6 (ANODE); also elsewhere on the board
VBUS_USB_SENSE: C10.1, R3.2, R4.1; also elsewhere on the board
VIN_EXT: F1.1, J1.1
VIN_EXT_P: C1.1, C2.1, D1.2 (A2), F1.2, Q1.1 (S), Q1.2 (S), Q1.3 (S), R1.1, U1.3 (EN), U1.6 (ANODE); also elsewhere on the board
VIN_EXT_SENSE: C9.1, R1.2, R2.1; also elsewhere on the board
VSYS: R126.2, U43.8 (Vbus), U43.9 (Vin-); also elsewhere on the board
VSYS_OR: C7.1, C8.1, Q1.5 (D), Q2.5 (D), Q3.5 (D), R126.1, U1.4 (CATHODE), U2.4 (CATHODE), U3.4 (CATHODE), U43.10 (Vin+); also elsewhere on the board

Notes on the sheet:
SOURCE OR-ING
Highest voltage wins, no control logic: VIN_EXT 24 V > PD 15-20 V > PoE 12 V > USB 5 V (J2 or J5). Each source enters through an MX74700T ideal diode: no back-feeding of a host, a PoE module or a supply. The firmware identifies the active source from the ADC inputs and U43, and derives the power bu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
From the shield (J_SHIELD_SVC 33-34) or the terminal block J1
From the USB-C PD sheet (STUSB4500 sink switch)
From the PoE module (DP5700, isolated 12 V)
From the USB HS sheet (ideal diode 5, J5)
Address 0x41 (A1 = GND, A0 = VS)
VSYS: 4.5-24 V, to the +5V buck (LMR33630) and the VIN_BUS boost (LM5155). U43 reads everything drawn from the active source.
ADC dividers 100k / 10k: 24 V -> 2.18 V; the TVS clamp (38.9 V) gives 3.54 V through 100 kΩ, 35 µA into the pin protection. Inputs: PF12, PF13, PF14. VSYS: U43.

Board: 4 copper layers, 441 parts (0 on the bottom side), 324 nets, no tracks yet.

Other parts of the board:
ENC1: Enclosure
H1, H4, H5, H6: M3 enclosure; MountingHole_3.2mm_M3
H2, H3: M3 shield and enclosure; MountingHole_3.2mm_M3
